# Keil uVision project Set_Nhiet_Do_Khoangcach(ADC0808).uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Set_Nhiet_do +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Main.c Thu_Vien_LCD.c Thu_Vien_LCD.h
